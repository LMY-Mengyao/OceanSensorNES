## boards/nodic/devoceansensor/Kconfig.defconfig
```kconfig
if BOARD_DEVOCEANSENSOR

config BT_CTLR
	default BT

endif # BOARD_DEVOCEANSENSOR
```
